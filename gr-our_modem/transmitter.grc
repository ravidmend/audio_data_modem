options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: transmitter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: our_modem_preprocess_0
  id: our_modem_preprocess
  parameters:
    fs: samp_rate
    input_str: '"aaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaa"'
    t: '0.001'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [our_modem_preprocess_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
