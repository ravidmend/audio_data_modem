options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: transmitter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: our_modem_preprocess_0
  id: our_modem_preprocess
  parameters:
    fs: samp_rate
    input_str: '"aaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaa"'
    t: '0.1'
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', qtgui_sink_x_0_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_0, '0']
- [analog_wfm_tx_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_tx_0, '0', qtgui_sink_x_0_0_0, '0']
- [blocks_throttle2_0, '0', analog_wfm_tx_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [our_modem_preprocess_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
