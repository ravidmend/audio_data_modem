options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: audio_to_text
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: t
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1.5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_wfm_rcv_0_1
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    num_outputs: '2'
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: abcde_10_audio.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: our_modem_postprocessor_0_0
  id: our_modem_postprocessor
  parameters:
    fs: samp_rate
    sensitivity: '1.5'
    t: t
    timeout: '0'
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '2'
    type: ccc
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_wfm_rcv_0_1, '0', our_modem_postprocessor_0_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_float_to_complex_1, '0', blocks_add_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_1, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_1, '1']
- [rational_resampler_xxx_0_0_0, '0', analog_wfm_rcv_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
