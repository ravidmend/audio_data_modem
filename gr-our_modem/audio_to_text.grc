options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: audio_to_text
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: my_string
  id: variable
  parameters:
    value: '"abcde"*10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: t
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1.5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '1.5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    num_outputs: '2'
    samp_rate: samp_rate
  states: {}
- name: audio_source_0_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: why_are_you_gay_audio
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: abcde_10_audio
    nchan: '2'
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '600'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: our_modem_postprocessor_0
  id: our_modem_postprocessor
  parameters:
    fs: samp_rate
    sensitivity: '0.1'
    t: t
    timeout: '0.333'
  states: {state: disabled}
- name: our_modem_postprocessor_0_0
  id: our_modem_postprocessor
  parameters:
    fs: samp_rate
    sensitivity: '0.1'
    t: t
    timeout: '0.333'
  states: {}
- name: our_modem_postprocessor_0_0_0
  id: our_modem_postprocessor
  parameters:
    fs: samp_rate
    sensitivity: '0.1'
    t: t
    timeout: '0.333'
  states: {state: disabled}
- name: our_modem_preprocess_0
  id: our_modem_preprocess
  parameters:
    fs: samp_rate
    input_str: my_string
    t: t
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_sink_x_0_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_wfm_rcv_0, '0', low_pass_filter_0, '0']
- [analog_wfm_rcv_0, '0', our_modem_postprocessor_0_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_sink_x_0_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_sink_x_0_0_0_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_0, '0']
- [analog_wfm_tx_0, '0', blocks_complex_to_real_0, '0']
- [analog_wfm_tx_0, '0', qtgui_sink_x_0_0_0, '0']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '1', blocks_float_to_complex_0, '1']
- [audio_source_0_0, '0', qtgui_sink_x_0_0_0_0_0, '0']
- [blocks_add_xx_0, '0', analog_wfm_rcv_0, '0']
- [blocks_add_xx_0_0, '0', analog_wfm_rcv_0, '0']
- [blocks_complex_to_real_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_float_to_complex_0, '0', analog_wfm_rcv_0, '0']
- [blocks_float_to_complex_0, '0', blocks_add_xx_0_0, '0']
- [blocks_throttle2_0, '0', analog_wfm_tx_0, '0']
- [blocks_throttle2_0, '0', our_modem_postprocessor_0, '0']
- [blocks_throttle2_0, '0', our_modem_postprocessor_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [low_pass_filter_0, '0', our_modem_postprocessor_0_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0, '0']
- [our_modem_preprocess_0, '0', analog_wfm_tx_0, '0']
- [our_modem_preprocess_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
