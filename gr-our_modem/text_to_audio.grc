options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: text_to_audio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: my_string
  id: variable
  parameters:
    value: '"abcde"*100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: t
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_24
    file: abcde_10_audio.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: '48000'
  states: {}
- name: our_modem_preprocess_0
  id: our_modem_preprocess
  parameters:
    fs: samp_rate
    input_str: my_string
    t: t
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '3'
    type: ccc
  states: {}

connections:
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [our_modem_preprocess_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
